# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Lib;.\Driver
  group Lib
    ./Lib/: ADC.c ADC_Isr.c Delay.c GPIO.c NVIC.c UART.c
  group Driver
    ./Driver/: NIXIE.c NTC.c
  group User
    ./User/: main.c
