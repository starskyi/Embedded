# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\USB;.\Lib;.\Driver
  group Lib
    ./Lib/: Delay.c GPIO.c NVIC.c UART.c
  group USB
    ./USB/: usb.c usb_desc.c usb_req_class.c usb_req_std.c usb_req_vendor.c util.c
  group Driver
    ./Driver/: Button.c
  group User
    ./User/: main.c
